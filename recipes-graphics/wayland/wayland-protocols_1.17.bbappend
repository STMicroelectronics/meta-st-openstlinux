FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-linux-dmabuf-Add-support-for-YUV-Full-color-range.patch"

