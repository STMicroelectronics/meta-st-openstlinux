FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-PLUGIN-load-libpythonxx.x.so.1.0.patch"
