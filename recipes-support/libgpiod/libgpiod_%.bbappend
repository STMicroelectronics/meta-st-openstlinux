PACKAGECONFIG = "cxx python3"
