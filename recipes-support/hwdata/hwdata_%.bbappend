BBCLASSEXTEND += "native nativesdk"

