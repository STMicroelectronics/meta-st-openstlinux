FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

CXXFLAGS += "-DEIGEN_MPL2_ONLY"
CFLAGS += "-DEIGEN_MPL2_ONLY"
