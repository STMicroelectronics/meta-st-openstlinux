PACKAGECONFIG = " \
    wayland-client \
    wayland-server \
    wayland-egl \
"

