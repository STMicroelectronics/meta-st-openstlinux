PACKAGECONFIG:remove = " qt5"
