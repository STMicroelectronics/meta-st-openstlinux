RDEPENDS_packagegroup-framework-tools-ui_remove_sticommon = " glmark2 "
