FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-authorize-pulse-audio-request-via-dbus.patch"

