SYSTEMD_AUTO_ENABLE = "disable"
INITSCRIPT_PARAMS = "disable"
