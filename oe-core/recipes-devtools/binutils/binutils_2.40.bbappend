# look for files in the layer first
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

