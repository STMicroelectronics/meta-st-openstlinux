FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-Add-support-for-ARM-Thumb-branches-with-instruction-.patch "
