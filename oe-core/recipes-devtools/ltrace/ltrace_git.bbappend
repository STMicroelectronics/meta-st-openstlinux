FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " file://0001-Add-support-for-ARM-Thumb-branches-with-instruction-.patch "
