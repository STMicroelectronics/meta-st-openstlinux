EXTRA_OECONF += "DEB_HOST_ARCH=${DPKG_ARCH}"
