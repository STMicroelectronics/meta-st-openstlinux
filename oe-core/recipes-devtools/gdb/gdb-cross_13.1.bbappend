FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI:append = "file://gdb/0010-fix-gdb-cross-arm-compilation-with-YOCTO-build-syste.patch"
