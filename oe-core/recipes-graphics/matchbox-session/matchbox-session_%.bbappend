ALTERNATIVE_PRIORITY = "99"
