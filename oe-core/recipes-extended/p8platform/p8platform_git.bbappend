RDEPENDS:${PN}-dev = ""
PACKAGES:remove = "${PN}"
