RDEPENDS:${PN} =+ "openssh-scp openssh-ssh openssh-sshd openssh-keygen"
