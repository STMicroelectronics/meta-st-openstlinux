FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0050-timesyncd-Use-recvmsg-instead-of-recvmsg_safe.patch "
