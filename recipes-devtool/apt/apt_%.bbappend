RDEPENDS:${PN} += " gnupg "

